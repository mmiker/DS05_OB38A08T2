# Keil uVision project DS05.uvproj, settings and files
target Target (MCS-51)
  device: OB38A08T2 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0x017F) CLOCK(16000000)
  output: DS05 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc;..\mmi_inc;..\dqiot_inc
  asm include: ..\inc
  group Source
    ./: STARTUP_OB38A08T2.A51
    ../src/: Main.c InitROM.asm Audio.c Bsp.c Fps.c I2C.c Led.c Timer.c Touch.c UART0.c EEPROM.c ADC.c
  group dqiot_src
    ../dqiot_src/: dqiot_fp_sy.c
  group mmi_src
    ../mmi_src/: mmi_fps.c
